# Keil uVision project LeakDetector.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LeakDetector
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F10X_MD
  c include: .\User;.\Firmware\CMSIS;.\Firmware\CMSIS\GD\GD32F10x\Include;.\Firmware\GD32F10x_standard_peripheral\Include;.\Int;.\Mid;.\App
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
    ./Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_md.s
  group User
    ./User/: main.c
  group GD32_Library
    ./Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_misc.c gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group Int
    ./Int/: int_debug_uart.c int_buzzer.c int_i2c.c int_oled.c int_adc_i2c.c int_sgm58031.c int_hc4066.c int_hef4052.c
  group Mid
    ./Mid/: mid_measure.c
  group App
    ./App/: app_leak.c app_location.c app_display.c
